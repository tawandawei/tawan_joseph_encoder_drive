<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Speed_control_test_FreeRTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
